# IAR project mm32_web_v7.ewp, settings and files
configuration MB039 (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __MM3U1; __MM32_MB039; __MDM2803; CLOCK=8000000; USER_DEBUG
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\app\web\inc; ..\..\app\web\port; ..\..\bsp\inc; ..\..\driver\inc; ..\..\lib\HAL_lib\inc; ..\..\lib\startup\inc; ..\..\app\web\arch; ..\..\thirdParty\FreeRTOS\include; ..\..\thirdParty\FreeRTOS\portable\IAR\ARM_CM3; .\...\thirdParty\lwIP\src; ..\..\thirdParty\lwIP\src\arch; ..\..\thirdParty\lwIP\src\include; ..\..\thirdParty\lwIP\src\include\compat; ..\..\thirdParty\lwIP\src\include\netif; ..\..\thirdParty\lwIP\src\include\lwip\; ..\..\thirdParty\lwIP\src\include\lwip\apps; ..\..\thirdParty\lwIP\src\include\lwip\priv; ..\..\thirdParty\lwIP\src\include\lwip\prot; ..\..\app\web; ..\..\app\web\arch; ..\..\thirdParty\LwIP\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\app\web\port
  OBJCOPY.OOCOutputFile: mm32_web_v7.srec
  prebuild: $WS_DIR$\app\web\makefsdata.bat  $WS_DIR$
  ILINK.IlinkOutputFile: uid.out
  ILINK.IlinkIcfFile: mm32_web.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../app/web/: main.c
  group app/config/freertos
    ../../thirdParty/FreeRTOS/portable/MemMang/: heap_4.c
    ../../thirdParty/FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group app/config/lwip
    ../../app/web/arch/: ethernetif.c sys_arch.c
  group app/ethernet
    ../../app/web/: eth.c http_server.c
  group app/ethernet/http
    ../../thirdParty/LwIP/src/apps/http/: fs.c httpd.c
  group app/led
    ../../app/web/: led.c
  group app/uart
    ../../app/web/: console.c
  group bsp
    ../../bsp/: bsp.c bsp_adc.c bsp_beep.c bsp_can.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_eth.c bsp_i2c.c bsp_key.c bsp_lan8720.c bsp_lcd.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_spi.c bsp_tim.c bsp_uart.c
  group lib/freertos
    ../../thirdParty/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib/hal
    ../../lib/HAL_lib/: common.c hal_adc.c hal_aes.c hal_bkp.c hal_can.c hal_comp.c hal_crc.c hal_crs.c hal_dac.c hal_dbg.c hal_div.c hal_dma.c hal_eth.c hal_exti.c hal_flash.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_nvic.c hal_opamp.c hal_pwr.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_wwdg.c
  group lib/lwip/api
    ../../thirdParty/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lib/lwip/core
    ../../thirdParty/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lib/lwip/core/ipv4
    ../../thirdParty/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lib/lwip/core/ipv6
    ../../thirdParty/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lib/lwip/netif
    ../../thirdParty/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lib/lwip/netif/ppp
    ../../thirdParty/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lib/lwip/netif/ppp/polarssl
    ../../thirdParty/LwIP/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group system
    ../../lib/startup/: mm32_startup.c mm32_system.c
